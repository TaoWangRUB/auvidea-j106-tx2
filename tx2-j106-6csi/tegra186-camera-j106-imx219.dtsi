/*
 * tegra186-camera-j106-imx219.dtsi
 *
 * Auvidea J106 carrier + Jetson TX2 : 6x Sony IMX219 (Raspberry Pi v2) CSI-2 cameras.
 *
 * Derived from the working TX1 device tree (L4T R24.2.1, tegra210-imx219.dts) and
 * ported to the L4T R32.2.1 "tegracam" binding using NVIDIA's
 * tegra186-camera-imx274-dual.dtsi as the structural template.
 *
 * The IMX219 driver (compatible "nvidia,imx219") already ships in the R32 kernel, so
 * no driver patch is required - this device tree is the only addition needed.
 *
 * ============================ HARDWARE (J106 carrier) ============================
 * 6 cameras across 3 i2c buses, 2 per bus. The J106 i2c address shifter (default
 * shift = 2) puts the 2nd ("south") camera of each bus at 0x12 instead of 0x10.
 * All 6 reset lines are tied together and driven by ONE GPIO.
 *
 *  Cam  CSI  serial    i2c bus (TX2)        Linux bus  addr   J106 connector
 *  ---  ---  --------  -------------------  ---------  -----  --------------
 *   A    0   serial_a  gen2_i2c @c240000    i2c-1      0x10   CSI-A (0-N)
 *   B    1   serial_b  gen2_i2c @c240000    i2c-1      0x12   CSI-B (0-S, shifted)
 *   C    2   serial_c  cam_i2c  @3180000    i2c-2      0x10   CSI-C (6-N)
 *   D    3   serial_d  cam_i2c  @3180000    i2c-2      0x12   CSI-D (6-S, shifted)
 *   E    4   serial_e  gen8_i2c @c250000    i2c-7      0x10   CSI-E (2-N)
 *   F    5   serial_f  gen8_i2c @c250000    i2c-7      0x12   CSI-F (2-S, shifted)
 *
 * ============================ VERIFIED FROM WEB RESEARCH ========================
 * The two previously-open values are now resolved from working J106+TX2 reports:
 *
 *  - Shared camera RESET GPIO = TEGRA_MAIN_GPIO(R, 5), driven via a gpio-hog
 *    (output-high) on gpio@2200000, and referenced ACTIVE_LOW by each sensor.
 *    Source: working IMX219-on-J106-CSI-E thread (NVIDIA forums 122966) and the
 *    Auvidea J106/TX2 firmware (sysfs gpio 461 on R28 == same physical pin).
 *  - CSI-E confirmed enumerating as "imx219 7-0010" on i2c@c250000 (same thread).
 *  - CSI-A/B on i2c@c240000 per Auvidea's tegra186-camera-imx219-rr.dtsi.
 *
 * ===================== LIVE HARDWARE VERIFIED (2026-06-08) ======================
 * Probed the actual TX2 (L4T R32.7.6, kernel 4.9.337). After releasing the reset:
 *   - RESET GPIO = sysfs 461 = TEGRA_MAIN_GPIO(R, 5) (chip base 320 + 141). Driving
 *     it 0->1 (active-low release) made the sensors ACK. => reset value CONFIRMED.
 *   - i2c@3180000 (i2c-2):  0x10 + 0x12 ACK  => CSI-C/D bus CONFIRMED.
 *   - i2c@c250000 (i2c-7):  0x10 + 0x12 ACK  => CSI-E/F bus CONFIRMED.
 *   - i2c@c240000 (i2c-1):  0x10 ACK (5th cam added) => CSI-A/B bus CONFIRMED.
 * NOTE: build the DTB against R32.7.x sources (board runs 4.6.x, not the BSP's 4.2.2).
 *
 * Still recommended: when the 6th camera is added it will appear at 0x12 on i2c-1.
 * Cross-check against Auvidea's tegra186-camera-imx219-rr.dtsi if any port misbehaves.
 * Camera power: RPi modules are powered directly on the J106; the avdd/iovdd/dvdd
 * string props below are nominal - wire to real supplies only if your build needs it.
 * ===============================================================================
 */

#include <dt-bindings/clock/tegra186-clock.h>
#include <dt-bindings/gpio/tegra186-gpio.h>
#include <dt-bindings/gpio/gpio.h>

/* All 6 connectors share one reset line on the J106, driven by ONE GPIO.
 * VERIFIED: TEGRA_MAIN_GPIO(R, 5) on TX2 (NVIDIA forum 122966, Auvidea firmware). */
#define J106_CAM_RST	TEGRA_MAIN_GPIO(R, 5)

/* Reusable per-mode property blocks for a 2-lane IMX219 on a given serial interface.
 *
 * ALL FIVE driver modes must be present, in DRIVER TABLE ORDER. Argus selects a
 * sensor mode by DT index and passes that index straight to the kernel driver
 * (use_sensor_mode_id), which uses it to pick the register table from
 * imx219_mode_tbls.h. With only 2 DT modes, "mode1" (1080p) selected driver
 * table[1] = 3264x1848 -> sensor lines wider than VI expected -> ChanselFault
 * PIXEL_LONG_LINE -> every Argus capture aborted after frame 2 (root-caused
 * 2026-06-13, README §7.9).
 *
 * Frame rates are derated for the J106's lowered MIPI rate (680 Mbps/lane,
 * imx219_mode_tbls.h PLL_OP_MPY 114->85 => pixel rate 136 Mpix/s; the 720p120
 * mode table was not modified and still runs 816 Mbps => 163.2 Mpix/s).
 * max_framerate must satisfy: pix_clk_hz / (line_length * fps) >= minimum
 * frame_length (active_h + blanking). Advertising the stock 21/30 fps made
 * Argus program a frame_length SHORTER than the frame itself, truncating every
 * frame -> ChanselFault PIXEL_INCOMPLETE (the other half of the same root cause). */
#define IMX219_MODE_COMMON(_iface)						\
	mclk_khz = "24000";							\
	num_lanes = "2";							\
	tegra_sinterface = _iface;						\
	phy_mode = "DPHY";							\
	discontinuous_clk = "no";						\
	dpcm_enable = "false";							\
	cil_settletime = "0";							\
	mode_type = "bayer";							\
	pixel_phase = "rggb";							\
	csi_pixel_bit_depth = "10";						\
	readout_orientation = "0";						\
	inherent_gain = "1";							\
	gain_factor = "1000000";						\
	min_gain_val = "1000000";						\
	max_gain_val = "16000000";						\
	step_gain_val = "1";							\
	default_gain = "1000000";						\
	min_hdr_ratio = "1";							\
	max_hdr_ratio = "1";							\
	framerate_factor = "1000000";						\
	min_framerate = "2000000";						\
	step_framerate = "1";							\
	exposure_factor = "1000000";						\
	min_exp_time = "13";							\
	max_exp_time = "683709";						\
	step_exp_time = "1";							\
	default_exp_time = "33334";						\
	embedded_metadata_height = "2";

/* driver table[0]: 3264x2464. 136e6/(3448*2497 lines) = 15.8 fps max. */
#define IMX219_MODE0(_iface)							\
	IMX219_MODE_COMMON(_iface)						\
	active_w = "3264";							\
	active_h = "2464";							\
	line_length = "3448";							\
	mclk_multiplier = "5.67";						\
	pix_clk_hz = "136000000";						\
	max_framerate = "15000000";						\
	default_framerate = "15000000";

/* driver table[1]: 3264x1848. 136e6/(3448*1881 lines) = 20.9 fps max. */
#define IMX219_MODE1(_iface)							\
	IMX219_MODE_COMMON(_iface)						\
	active_w = "3264";							\
	active_h = "1848";							\
	line_length = "3448";							\
	mclk_multiplier = "5.67";						\
	pix_clk_hz = "136000000";						\
	max_framerate = "20000000";						\
	default_framerate = "20000000";

/* driver table[2]: 1920x1080. frame_length floor ~1112 lines allows 30 fps
 * (136e6/(3448*30) = 1314 lines > 1112). */
#define IMX219_MODE2(_iface)							\
	IMX219_MODE_COMMON(_iface)						\
	active_w = "1920";							\
	active_h = "1080";							\
	line_length = "3448";							\
	mclk_multiplier = "5.67";						\
	pix_clk_hz = "136000000";						\
	max_framerate = "30000000";						\
	default_framerate = "30000000";

/* driver table[3]: 1640x1232 2x2-binned, FULL FoV (full sensor array, /2 each
 * axis). FRM_LENGTH=0x06E2=1762 lines, LINE_LENGTH=0x0D78=3448. At the
 * J106-lowered 680 Mbps PLL: 136e6/(3448*1762) = 22.4 fps max. This is the
 * wide-angle mode for the omni/VIO rig -- 1280x720 and 1080p are center CROPS
 * (~94 deg), this keeps the lens's full FoV. Driver register table + frmfmt
 * entry already ship in imx219_mode_tbls.h (PLL already at 680). */
#define IMX219_MODE3(_iface)							\
	IMX219_MODE_COMMON(_iface)						\
	active_w = "1640";							\
	active_h = "1232";							\
	line_length = "3448";							\
	mclk_multiplier = "5.67";						\
	pix_clk_hz = "136000000";						\
	max_framerate = "22000000";						\
	default_framerate = "22000000";

/* driver table[4]: 1280x720 2x2-binned center crop. FRM_LENGTH=0x0370=880 lines.
 * 136e6/(3448*880) = 44.8 fps max at the J106-lowered 680 Mbps PLL.
 * NOTE: the stock 720p120 high-rate table is commented OUT in
 * imx219_mode_tbls.h, so mode_table[4] = imx219_mode_1280x720_60fps (680 Mbps).
 * The old DT "110 fps" entry was a PHANTOM: Argus advertised 1280x720@110 from
 * this DT node, but the sensor has no 816 Mbps table to back it and fell back to
 * the 680 Mbps register table (~44 fps). Advertise the honest rate here. */
#define IMX219_MODE4(_iface)							\
	IMX219_MODE_COMMON(_iface)						\
	active_w = "1280";							\
	active_h = "720";							\
	line_length = "3448";							\
	mclk_multiplier = "5.67";						\
	pix_clk_hz = "136000000";						\
	max_framerate = "44000000";						\
	default_framerate = "44000000";

/* Common hw-resource block placed in every sensor node.
 * All 6 J106 sensors share ONE physical reset line (gpio 461). The patched
 * imx219 driver (patches/0001-imx219-share-reset-gpio-j106.patch) tolerates
 * -EBUSY on gpio_request() and never frees the line, so every sensor can
 * reference the same real reset-gpios below - no dummy pins needed. */
#define IMX219_HW_RESOURCES							\
	compatible = "nvidia,imx219";						\
	devnode = "video0";							\
	physical_w = "3.680";							\
	physical_h = "2.760";							\
	sensor_model = "imx219";						\
	use_sensor_mode_id = "true";						\
	clocks = <&tegra_car TEGRA186_CLK_EXTPERIPH1>,				\
		 <&tegra_car TEGRA186_CLK_PLLP_OUT0>;				\
	clock-names = "extperiph1", "pllp_grtba";				\
	mclk = "extperiph1";							\
	clock-frequency = <24000000>;						\
	reset-gpios = <&tegra_main_gpio J106_CAM_RST GPIO_ACTIVE_LOW>;		\
	avdd-reg = "vana";							\
	iovdd-reg = "vif";							\
	dvdd-reg = "vdig";						\
	vana-supply = <&cam_dummy_reg>;					\
	vif-supply = <&cam_dummy_reg>;					\
	vdig-supply = <&cam_dummy_reg>;

/* ===================== IMX296 (CSI-F) =====================
 *
 * Port F carries a Sony IMX296LQR global shutter module instead of an IMX219.
 * Three things differ from the IMX219 ports and all three are load-bearing:
 *
 *  - ONE MIPI lane (not two). The IMX296 is a single-lane sensor at 1188 Mbps;
 *    bus-width must be 1 at all three hops (sensor -> nvcsi -> vi).
 *  - NO reset-gpios and NO mclk. The shared reset line is already released
 *    high by the j106-camera-reset-release hog and the five IMX219s depend on
 *    it staying that way, so the imx296 driver never touches it. The module is
 *    self-clocked, so it does not need (and cannot use) the shared 24 MHz
 *    extperiph1 MCLK - the IMX296 only accepts 37.125/54/74.25 MHz.
 *  - Bayer order is BGGR, not RGGB.
 *
 * embedded_metadata_height = "2": the sensor emits two lines of embedded data
 * (CSI-2 DT 0x12) ahead of the image. Per the datasheet the full vertical
 * structure is FS + 2 embedded + 6 null (DT 0x10) + 4 optical black (DT 0x37)
 * + active image (DT 0x2b) + FE; only the DT 0x12 lines are counted here.
 */
#define IMX296_MODE_COMMON(_iface)						\
	mclk_khz = "74250";							\
	num_lanes = "1";							\
	tegra_sinterface = _iface;						\
	phy_mode = "DPHY";							\
	discontinuous_clk = "no";						\
	dpcm_enable = "false";							\
	cil_settletime = "0";							\
	mode_type = "bayer";							\
	pixel_phase = "bggr";							\
	csi_pixel_bit_depth = "10";						\
	readout_orientation = "0";						\
	inherent_gain = "1";							\
	gain_factor = "10";							\
	min_gain_val = "0";			/* 0 dB */			\
	max_gain_val = "480";			/* 48 dB */			\
	step_gain_val = "1";			/* 0.1 dB */			\
	default_gain = "0";							\
	min_hdr_ratio = "1";							\
	max_hdr_ratio = "1";							\
	framerate_factor = "1000000";						\
	min_framerate = "2000000";						\
	step_framerate = "1";							\
	exposure_factor = "1000000";						\
	min_exp_time = "30";							\
	max_exp_time = "500000";						\
	step_exp_time = "1";							\
	default_exp_time = "16000";						\
	embedded_metadata_height = "2";

/* All-pixel scan mode, 1456x1088 RAW10, 60.3 fps (datasheet).
 * line_length 1760 px = HMAX 1100 x (1188 Mbps / 10 bpp) / 74.25 MHz, i.e. the
 * 14.815 us line time expressed in pixels at the 118.8 Mpx/s output rate. */
#define IMX296_MODE0(_iface)							\
	IMX296_MODE_COMMON(_iface)						\
	active_w = "1456";							\
	active_h = "1088";							\
	line_length = "1760";							\
	mclk_multiplier = "1.6";						\
	pix_clk_hz = "118800000";						\
	max_framerate = "60300000";						\
	default_framerate = "60300000";

/* No clocks/mclk and no reset-gpios on purpose - see the note above.
 *
 * inck-frequency is the module's own oscillator. MEASURED, not assumed: the
 * sensor has no register reporting its input clock, so it was determined by
 * capturing at the sensor's power-on default (74.25 MHz) and reading the frame
 * rate back - timing scales by (actual INCK / assumed INCK), so the three legal
 * clocks are cleanly distinguishable at 60.4 / 43.9 / 30.2 fps. Measured
 * 600 frames in 13.905 s = 43.15 fps against 13.664 s expected for 54 MHz
 * (the +0.24 s gap is fixed stream-start overhead - it is identical on a
 * 180-frame run - not a rate error); 74.25 MHz was off by 4.0 s and
 * 37.125 MHz by 6.0 s. Hence 54 MHz.
 *
 * The driver accepts only 37125000, 54000000 or 74250000 and uses this to pick
 * INCKSEL[0..3] and CTRL418C.
 * Physical size: 1456 x 1088 at the IMX296's 3.45 um pixel pitch. */
#define IMX296_HW_RESOURCES							\
	compatible = "nvidia,imx296";						\
	devnode = "video0";							\
	physical_w = "5.023";							\
	physical_h = "3.754";							\
	sensor_model = "imx296";						\
	use_sensor_mode_id = "true";						\
	inck-frequency = <54000000>;		/* measured - see above */	\
	avdd-reg = "vana";							\
	iovdd-reg = "vif";							\
	dvdd-reg = "vdig";							\
	vana-supply = <&cam_dummy_reg>;						\
	vif-supply = <&cam_dummy_reg>;						\
	vdig-supply = <&cam_dummy_reg>;

/ {
	/* Camera power on the J106: the Raspberry Pi IMX219 modules are powered
	 * directly from the carrier's CSI connectors (onboard LDOs), so there is
	 * no SoC-controllable rail. Provide one always-on dummy regulator to
	 * satisfy the imx219 driver's vana/vif/vdig regulator_get calls. */
	cam_dummy_reg: regulator@200 {
		compatible = "regulator-fixed";
		reg = <0x200>;
		regulator-name = "cam-dummy-reg";
		regulator-min-microvolt = <1800000>;
		regulator-max-microvolt = <1800000>;
		regulator-always-on;
		regulator-boot-on;
	};
};

/* Route the EXTPERIPH1 clock to the physical pin (PO0). Without this,
 * the pin defaults to GPIO mode (bit 10 set) and the 24 MHz MCLK never
 * reaches the IMX219 sensors.
 * This pin config is placed under the "common" pinctrl group which is
 * referenced by pinctrl-0 ("default") and applied at boot. */
/ {
	pinmux@2430000 {
		common {
			extperiph1_clk_po0 {
				nvidia,pins = "extperiph1_clk_po0";
				nvidia,function = "extperiph1";
				nvidia,tristate = <0>;
				nvidia,enable-input = <0>;
				nvidia,pull = <0>;
			};
		};
	};
};

/ {
	/* Release the shared camera reset at boot by hogging the line high.
	 * All 6 J106 CSI reset pins are tied together on this one GPIO.
	 * NOTE: the stock devkit DTB already defines a (disabled) hog node named
	 * "camera-control-output-high" on this very pin; we MUST use a distinct
	 * node name with explicit status="okay" so ours is not silently merged
	 * into the disabled stock node and is the one that actually claims and
	 * drives the line high (reset released for all sensors). */
	gpio@2200000 {
		j106-camera-reset-release {
			gpio-hog;
			output-high;
			gpios = <J106_CAM_RST 0>;
			label = "j106-cam-rst";
			status = "okay";
		};
	};
};

/ {
	host1x {
		/* -------- Video Input: 6 channels (CSI A..F) -------- */
		vi@15700000 {
			status = "okay";
			num-channels = <6>;
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					status = "okay";
					j106_vi_in0: endpoint {
						port-index = <0>;	/* CSI_A */
						bus-width = <2>;
						remote-endpoint = <&j106_csi_out0>;
						status = "okay";
					};
				};
				port@1 {
					reg = <1>;
					status = "okay";
					j106_vi_in1: endpoint {
						port-index = <1>;	/* CSI_B */
						bus-width = <2>;
						remote-endpoint = <&j106_csi_out1>;
						status = "okay";
					};
				};
				port@2 {
					reg = <2>;
					status = "okay";
					j106_vi_in2: endpoint {
						port-index = <2>;	/* CSI_C */
						bus-width = <2>;
						remote-endpoint = <&j106_csi_out2>;
						status = "okay";
					};
				};
				port@3 {
					reg = <3>;
					status = "okay";
					j106_vi_in3: endpoint {
						port-index = <3>;	/* CSI_D */
						bus-width = <2>;
						remote-endpoint = <&j106_csi_out3>;
						status = "okay";
					};
				};
				port@4 {
					reg = <4>;
					status = "okay";
					j106_vi_in4: endpoint {
						port-index = <4>;	/* CSI_E */
						bus-width = <2>;
						remote-endpoint = <&j106_csi_out4>;
						status = "okay";
					};
				};
				port@5 {
					reg = <5>;
					status = "okay";
					j106_vi_in5: endpoint {
						port-index = <5>;	/* CSI_F */
						bus-width = <1>;	/* IMX296: single lane */
						remote-endpoint = <&j106_csi_out5>;
						status = "okay";
					};
				};
			};
		};

		/* -------- NVCSI: 6 channels -------- */
		nvcsi@150c0000 {
			status = "okay";
			num-channels = <6>;
			#address-cells = <1>;
			#size-cells = <0>;
			channel@0 {
				reg = <0>;
				status = "okay";
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						status = "okay";
						j106_csi_in0: endpoint@0 {
							port-index = <0>;
							bus-width = <2>;
							remote-endpoint = <&j106_imx219_out0>;
							status = "okay";
						};
					};
					port@1 {
						reg = <1>;
						status = "okay";
						j106_csi_out0: endpoint@1 {
							remote-endpoint = <&j106_vi_in0>;
							status = "okay";
						};
					};
				};
			};
			channel@1 {
				reg = <1>;
				status = "okay";
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						status = "okay";
						j106_csi_in1: endpoint@2 {
							port-index = <1>;
							bus-width = <2>;
							remote-endpoint = <&j106_imx219_out1>;
							status = "okay";
						};
					};
					port@1 {
						reg = <1>;
						status = "okay";
						j106_csi_out1: endpoint@3 {
							remote-endpoint = <&j106_vi_in1>;
							status = "okay";
						};
					};
				};
			};
			channel@2 {
				reg = <2>;
				status = "okay";
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						status = "okay";
						j106_csi_in2: endpoint@4 {
							port-index = <2>;
							bus-width = <2>;
							remote-endpoint = <&j106_imx219_out2>;
							status = "okay";
						};
					};
					port@1 {
						reg = <1>;
						status = "okay";
						j106_csi_out2: endpoint@5 {
							remote-endpoint = <&j106_vi_in2>;
							status = "okay";
						};
					};
				};
			};
			channel@3 {
				reg = <3>;
				status = "okay";
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						status = "okay";
						j106_csi_in3: endpoint@6 {
							port-index = <3>;
							bus-width = <2>;
							remote-endpoint = <&j106_imx219_out3>;
							status = "okay";
						};
					};
					port@1 {
						reg = <1>;
						status = "okay";
						j106_csi_out3: endpoint@7 {
							remote-endpoint = <&j106_vi_in3>;
							status = "okay";
						};
					};
				};
			};
			channel@4 {
				reg = <4>;
				status = "okay";
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						status = "okay";
						j106_csi_in4: endpoint@8 {
							port-index = <4>;
							bus-width = <2>;
							remote-endpoint = <&j106_imx219_out4>;
							status = "okay";
						};
					};
					port@1 {
						reg = <1>;
						status = "okay";
						j106_csi_out4: endpoint@9 {
							remote-endpoint = <&j106_vi_in4>;
							status = "okay";
						};
					};
				};
			};
			channel@5 {
				reg = <5>;
				status = "okay";
				ports {
					#address-cells = <1>;
					#size-cells = <0>;
					port@0 {
						reg = <0>;
						status = "okay";
						j106_csi_in5: endpoint@10 {
							port-index = <5>;
							bus-width = <1>;	/* IMX296: single lane */
							remote-endpoint = <&j106_imx296_out5>;
							status = "okay";
						};
					};
					port@1 {
						reg = <1>;
						status = "okay";
						j106_csi_out5: endpoint@11 {
							remote-endpoint = <&j106_vi_in5>;
							status = "okay";
						};
					};
				};
			};
		};
	};

	/* ================= Strip stock devkit camera nodes =================
	 * The Approach-A DTB (decompiled stock + overlay) inherits NVIDIA's
	 * devkit camera graph. Two stock nodes are fatal on the J106:
	 *
	 *   tca9546@70 / i2cmux@70 — PCA9546 I2C muxes at address 0x70.
	 *   The J106 address shifter may respond to 0x70; the mux driver
	 *   writes channel-select bytes at probe, potentially misconfiguring
	 *   the shifter and breaking the 0x12 (south) cameras.
	 *   CORRELATION: the two buses WITH a stock mux (i2c-1, i2c-2) have
	 *   failing 0x12 cameras; the bus WITHOUT one (i2c-7) works.
	 *
	 *   ov23850_a@10 — address-collides with imx219_c@10 on i2c-2.
	 *
	 * The TX1 Auvidea BSP avoids this by removing the stock camera
	 * includes entirely (tegra210-jetson-cv-camera-modules.dtsi). */

	i2c@3180000 {
		/delete-node/ tca9546@70;
		/delete-node/ tca9548@77;
		/delete-node/ ov23850_a@10;
		/delete-node/ ov5693_c@36;
	};

	i2c@c240000 {
		/delete-node/ i2cmux@70;
		/delete-node/ ov23850_c@36;
	};

	/* ================= i2c bus gen2_i2c (CSI-A / CSI-B) -> i2c-1 ================= */
	i2c@c240000 {
		status = "okay";
		#address-cells = <1>;
		#size-cells = <0>;

		imx219_a@10 {
			IMX219_HW_RESOURCES
			reg = <0x10>;
			mode0 { IMX219_MODE0("serial_a") };
			mode1 { IMX219_MODE1("serial_a") };
			mode2 { IMX219_MODE2("serial_a") };
			mode3 { IMX219_MODE3("serial_a") };
			mode4 { IMX219_MODE4("serial_a") };
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					j106_imx219_out0: endpoint {
						port-index = <0>;
						bus-width = <2>;
						remote-endpoint = <&j106_csi_in0>;
					};
				};
			};
		};

		imx219_b@12 {
			IMX219_HW_RESOURCES
			reg = <0x12>;
			mode0 { IMX219_MODE0("serial_b") };
			mode1 { IMX219_MODE1("serial_b") };
			mode2 { IMX219_MODE2("serial_b") };
			mode3 { IMX219_MODE3("serial_b") };
			mode4 { IMX219_MODE4("serial_b") };
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					j106_imx219_out1: endpoint {
						port-index = <1>;
						bus-width = <2>;
						remote-endpoint = <&j106_csi_in1>;
					};
				};
			};
		};
	};

	/* ================= i2c bus cam_i2c (CSI-C / CSI-D) ================= */
	i2c@3180000 {
		status = "okay";
		#address-cells = <1>;
		#size-cells = <0>;

		imx219_c@10 {
			IMX219_HW_RESOURCES
			reg = <0x10>;
			mode0 { IMX219_MODE0("serial_c") };
			mode1 { IMX219_MODE1("serial_c") };
			mode2 { IMX219_MODE2("serial_c") };
			mode3 { IMX219_MODE3("serial_c") };
			mode4 { IMX219_MODE4("serial_c") };
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					j106_imx219_out2: endpoint {
						port-index = <2>;
						bus-width = <2>;
						remote-endpoint = <&j106_csi_in2>;
					};
				};
			};
		};

		imx219_d@12 {
			IMX219_HW_RESOURCES
			reg = <0x12>;
			mode0 { IMX219_MODE0("serial_d") };
			mode1 { IMX219_MODE1("serial_d") };
			mode2 { IMX219_MODE2("serial_d") };
			mode3 { IMX219_MODE3("serial_d") };
			mode4 { IMX219_MODE4("serial_d") };
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					j106_imx219_out3: endpoint {
						port-index = <3>;
						bus-width = <2>;
						remote-endpoint = <&j106_csi_in3>;
					};
				};
			};
		};
	};

	/* ============ i2c bus gen8_i2c (CSI-E / CSI-F) -> i2c-7 (CONFIRMED) ============ */
	i2c@c250000 {
		status = "okay";
		#address-cells = <1>;
		#size-cells = <0>;

		imx219_e@10 {
			IMX219_HW_RESOURCES
			reg = <0x10>;
			mode0 { IMX219_MODE0("serial_e") };
			mode1 { IMX219_MODE1("serial_e") };
			mode2 { IMX219_MODE2("serial_e") };
			mode3 { IMX219_MODE3("serial_e") };
			mode4 { IMX219_MODE4("serial_e") };
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					j106_imx219_out4: endpoint {
						port-index = <4>;
						bus-width = <2>;
						remote-endpoint = <&j106_csi_in4>;
					};
				};
			};
		};

		/* CSI-F: IMX296 global shutter.
		 *
		 * reg = 0x18 and not 0x34: the IMX296 answers at TWO addresses -
		 * a SLAMODE-strapped one (0x36 here, so this module straps
		 * SLAMODE=0) and a common one (0x1a) that is valid in both
		 * SLAMODE polarities. The carrier's address shifter XORs address
		 * bit 1, mapping them to 0x34 and 0x18 respectively. Using the
		 * common address keeps this node correct if the module is ever
		 * swapped for a differently-strapped one. */
		imx296_f@18 {
			IMX296_HW_RESOURCES
			reg = <0x18>;
			mode0 { IMX296_MODE0("serial_f") };
			ports {
				#address-cells = <1>;
				#size-cells = <0>;
				port@0 {
					reg = <0>;
					j106_imx296_out5: endpoint {
						port-index = <5>;
						bus-width = <1>;
						remote-endpoint = <&j106_csi_in5>;
					};
				};
			};
		};
	};

	/* Lens descriptor for Argus (nvarguscamerasrc). Raspberry Pi Camera v2
	 * is fixed-focus, f/2.0, 3.04 mm focal length. All 6 IMX219 share this. */
	j106_lens_imx219@J106 {
		min_focus_distance = "0.0";
		hyper_focal = "0.0";
		focal_length = "3.04";
		f_number = "2.0";
		aperture = "2.0";
	};

	/* ===================== tegra-camera-platform ===================== */
	tegra-camera-platform {
		compatible = "nvidia, tegra-camera-platform";

		/* 5 x IMX219 x 2 lanes + 1 x IMX296 x 1 lane = 11 lanes total */
		num_csi_lanes = <11>;
		max_lane_speed = <1500000>;
		min_bits_per_pixel = <10>;
		vi_peak_byte_per_pixel = <2>;
		vi_bw_margin_pct = <25>;
		max_pixel_rate = <240000>;
		isp_peak_byte_per_pixel = <5>;
		isp_bw_margin_pct = <25>;

		modules {
			module0 {
				status = "okay";
				badge = "imx219_topleft_csia";
				position = "topleft";
				orientation = "1";
				drivernode0 {
					status = "okay";
					pcl_id = "v4l2_sensor";
					devname = "imx219 1-0010";
					proc-device-tree = "/proc/device-tree/i2c@c240000/imx219_a@10";
				};
				drivernode1 {
					status = "okay";
					pcl_id = "v4l2_lens";
					proc-device-tree = "/proc/device-tree/j106_lens_imx219@J106/";
				};
			};
			module1 {
				status = "okay";
				badge = "imx219_topright_csib";
				position = "topright";
				orientation = "1";
				drivernode0 {
					status = "okay";
					pcl_id = "v4l2_sensor";
					devname = "imx219 1-0012";
					proc-device-tree = "/proc/device-tree/i2c@c240000/imx219_b@12";
				};
				drivernode1 {
					status = "okay";
					pcl_id = "v4l2_lens";
					proc-device-tree = "/proc/device-tree/j106_lens_imx219@J106/";
				};
			};
			module2 {
				status = "okay";
				badge = "imx219_centerleft_csic";
				position = "centerleft";
				orientation = "1";
				drivernode0 {
					status = "okay";
					pcl_id = "v4l2_sensor";
					devname = "imx219 2-0010";
					proc-device-tree = "/proc/device-tree/i2c@3180000/imx219_c@10";
				};
				drivernode1 {
					status = "okay";
					pcl_id = "v4l2_lens";
					proc-device-tree = "/proc/device-tree/j106_lens_imx219@J106/";
				};
			};
			module3 {
				status = "okay";
				badge = "imx219_centerright_csid";
				position = "centerright";
				orientation = "1";
				drivernode0 {
					status = "okay";
					pcl_id = "v4l2_sensor";
					devname = "imx219 2-0012";
					proc-device-tree = "/proc/device-tree/i2c@3180000/imx219_d@12";
				};
				drivernode1 {
					status = "okay";
					pcl_id = "v4l2_lens";
					proc-device-tree = "/proc/device-tree/j106_lens_imx219@J106/";
				};
			};
			module4 {
				status = "okay";
				badge = "imx219_bottomleft_csie";
				position = "bottomleft";
				orientation = "1";
				drivernode0 {
					status = "okay";
					pcl_id = "v4l2_sensor";
					devname = "imx219 7-0010";
					proc-device-tree = "/proc/device-tree/i2c@c250000/imx219_e@10";
				};
				drivernode1 {
					status = "okay";
					pcl_id = "v4l2_lens";
					proc-device-tree = "/proc/device-tree/j106_lens_imx219@J106/";
				};
			};
			module5 {
				status = "okay";
				badge = "imx296_bottomright_csif";
				position = "bottomright";
				orientation = "1";
				drivernode0 {
					status = "okay";
					pcl_id = "v4l2_sensor";
					devname = "imx296 7-0018";
					proc-device-tree = "/proc/device-tree/i2c@c250000/imx296_f@18";
				};
				/* NOTE: reuses the IMX219 lens descriptor. The IMX296
				 * module's optics have not been characterised, so
				 * rather than invent focal length / f-number values
				 * this points at the existing descriptor to keep
				 * Argus happy. Replace with a dedicated
				 * j106_lens_imx296 node once the lens is measured. */
				drivernode1 {
					status = "okay";
					pcl_id = "v4l2_lens";
					proc-device-tree = "/proc/device-tree/j106_lens_imx219@J106/";
				};
			};
		};
	};
};
